Commit message: still working on two cameras stuff

File: urdf/usb_cam.urdf (robot description, URDF)
Before this commit: robot usb_cam, 2 links, 1 joints
Links:
- removed link usb_cam
- added link usb_cam_thing
Joints:
- joint optical_frame_to_base: child usb_cam -> usb_cam_thing
